# IAR project TIM_TimeBase.ewp, settings and files
configuration TIM_TimeBase (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F4XX
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\Libraries\CMSIS\ST\STM32F4xx\Include; ..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Utilities\STM32F4-Discovery
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TIM_TimeBase.srec
  ILINK.IlinkOutputFile: TIM_TimeBase.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ../../../../Libraries/CMSIS/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group STM32F4-Discovery
    ../../../../Utilities/STM32F4-Discovery/: stm32f4_discovery.c
  group STM32F4xx_StdPeriph_Driver
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
  group User
    ../: asservissementCap.c asservissementVitesseAngulaire.c asservissementVitesseLineaire.c configTimer.c controleDistanceCapRobot.c controleMoteur.c FSM_USART_codePays.c FSM_USART_commande.c main.c stm32f4xx_it.c system_stm32f4xx.c USART_config.c
